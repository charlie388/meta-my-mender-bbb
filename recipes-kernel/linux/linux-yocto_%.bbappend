FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://kernel-config-can.cfg \
            file://0001-Add-can0-can1-in-device-tree.patch \
            "
